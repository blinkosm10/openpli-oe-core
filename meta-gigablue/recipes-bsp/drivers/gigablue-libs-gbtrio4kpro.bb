SRCDATE = "20250507"

require gigablue-libs.inc

SRC_URI[md5sum] = "72e3199db93bdfaf1da681cc61168c8a"
SRC_URI[sha256sum] = "2a14f8a7c6ee59d4197eaac9ed7d46f3fe5c9b65b7889c0ec4822835c865d241"
