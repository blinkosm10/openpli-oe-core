KV = "4.4.35"
SRCDATE = "20250507"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "e9ab5e965834d18bcbd2adfac5cf2491"
SRC_URI[sha256sum] = "9f206e0c01dfe701d28e4027a5837613fdfa41daf2d9f65bfcdc3c5703fb74ad"
