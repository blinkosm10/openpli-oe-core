KV = "4.4.35"
SRCDATE = "20240306"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "2cdf26f3dae95b460f3b14c84b8bea93"
SRC_URI[sha256sum] = "19365d9e3d68ccbd1556fc63a607d454e8f0d83302ce1b6e18fda95cad01af1e"
