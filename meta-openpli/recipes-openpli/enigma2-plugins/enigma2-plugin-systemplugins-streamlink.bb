DESCRIPTION = "Streamlink Proxy"

require conf/license/openpli-gplv2.inc

RDEPENDS_${PN} = "streamlink streamlinksrv"

PV = "1.0"

ALLOW_EMPTY_${PN} = "1"
