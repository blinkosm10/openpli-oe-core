FILESEXTRAPATHS:prepend := "${THISDIR}/gcc:"

SRC_URI:append = " file://0005-optional-libstdc.patch"
